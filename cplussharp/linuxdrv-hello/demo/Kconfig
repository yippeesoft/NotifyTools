## cplussharp/linuxdrv-hello/demo/Kconfig
```kconfig
config DEMO
    tristate "Demo Register Driver"
    default y
    help
    This is the demo driver for android system.
```
